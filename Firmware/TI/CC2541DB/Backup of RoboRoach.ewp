# IAR project Backup of RoboRoach.ewp, settings and files
configuration CC2541DK (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2541F256.i51
  ICC8051.CCDefines: INT_HEAP_LEN=3000; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=FALSE; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=TRUE; HAL_LED=TRUE; ACC_BMA250; DC_DC_P0_7
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\hal\target\CC2530EB; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\Profiles\Proximity; ..\..\Profiles\Roles; ..\..\Profiles\HidDev; ..\..\Profiles\Batt; ..\..\Profiles\Accelerometer; ..\..\Profiles\Keys; ..\..\Profiles\DevInfo
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\common\cc2540\ti_51ew_cc2540b.xcl
configuration RoboRoach (8051)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=3000; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=FALSE; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=FALSE; DC_DC_P0_7
configuration RoboRoach CC2541DK (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=3000; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=FALSE; POWER_SAVING; HAL_LCD=TRUE; HAL_LED=FALSE; CC2541DK; DC_DC_P0_7; ROBODEV
configuration RoboRoach DebugBoard (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=3000; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=FALSE; POWER_SAVING; HAL_LCD=TRUE; HAL_LED=FALSE; ROBODEV; DC_DC_P0_7
  group APP
    ../Source/: devinfoservice.c devinfoservice.h MCP4000.c MCP4000.h OSAL_RoboRoachApp.c roboRoach.h roboRoach_GATTprofile.c roboRoach_GATTprofile.h roboRoachApp.c roboRoachApp.h roboRoachApp_Main.c
  group HAL/Common
    ../../../../Components/hal/common/: hal_drivers.c
  group HAL/Include
    ../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2540EB/Config
    ../../../../Components/hal/target/CC2540EB/: hal_board_cfg.h
  group HAL/Target/CC2540EB/Drivers
    ../../../../Components/hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2540EB/Includes
    ../../../../Components/hal/target/CC2540EB/: hal_aes.h hal_ccm.h hal_dma.h hal_mcu.h hal_types.h
  group LIB
    ../../Libraries/CC2541DB/bin/: CC2541_BLE_peri.lib
    ../../Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group NPI
    ../../common/npi/npi_np/: npi.c npi.h npi_spi.c npi_uart.c
  group OSAL
    ../../../../Components/ble/include/: bcomdef.h
    ../../../../Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../Profiles/Batt/: battservice.c battservice.h
    ../../Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h peripheral.c peripheral.h
    ../../Include/: gapgattserver.h gattservapp.h
    ../../../../Components/ble/host/: gatt_uuid.c
    ../../../../Components/ble/include/: gatt_uuid.h
    ../../Profiles/Proximity/: proxreporter.c proxreporter.h
    ../../Profiles/Keys/: simplekeys.c simplekeys.h
  group TOOLS
    ../../config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../common/cc2540/: lnk51ew_cc2530b_banked_rom_data.xcl lnk_banked_rom_data.xcl OnBoard.c OnBoard.h
