# IAR project RoboRoachApp.ewp, settings and files
configuration S2 Release (8051)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2540F256.i51
  ICC8051.CCDefines: CC2540; INT_HEAP_LEN=1536; AT_DEBUG
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\source; ..\..\..\..\components\at\include; ..\..\..\..\components\ble\include; ..\..\..\..\components\hal\include; ..\..\..\..\components\osal\include; ..\..\..\profiles\include
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  postbuild: ..\..\..\Tools\BrxBuilder.exe T="S2" A="$TARGET_PATH$"
  XLINK.XclFile: ..\..\..\Tools\Linker\br_le40_sx.xcl
configuration S2 Debug (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CC2540; INT_HEAP_LEN=1536; DEBUG; AT_DEBUG; OSALMEM_METRICS
  ICC8051.CCIncludePath2: ..\source; ..\..\..\..\components\at\include; ..\..\..\..\components\ble\include; ..\..\..\..\components\hal\include; ..\..\..\..\components\osal\include; ..\..\..\Profiles\Include
  XLINK.XclFile: ..\..\..\Tools\Linker\ti_51ew_cc2540b.xcl
configuration S3 Release (8051)
  as the first configuration, except:
  ICC8051.CCDefines: CC2541; INT_HEAP_LEN=1536
  ICC8051.CCIncludePath2: ..\source; ..\..\..\..\components\at\include; ..\..\..\..\components\ble\include; ..\..\..\..\components\hal\include; ..\..\..\..\components\osal\include
  postbuild: ..\..\..\Tools\BrxBuilder.exe T="S3" A="$TARGET_PATH$"
configuration S3 Debug (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CC2541; INT_HEAP_LEN=1536; DEBUG; AT_DEBUG; OSALMEM_METRICS
  ICC8051.CCIncludePath2: as above
  XLINK.XclFile: ..\..\..\Tools\Linker\ti_51ew_cc2540b.xcl
configuration PAN1720 Release (8051)
  as the first configuration, except:
  ICC8051.CCDefines: CC2540; INT_HEAP_LEN=1536
  ICC8051.CCIncludePath2: as above
  postbuild: ..\..\..\Tools\BrxBuilder.exe T="PAN1720" A="$TARGET_PATH$"
configuration PAN1720 Debug (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CC2540; INT_HEAP_LEN=1536; DEBUG; AT_DEBUG; OSALMEM_METRICS
  ICC8051.CCIncludePath2: as above
  XLINK.XclFile: ..\..\..\Tools\Linker\ti_51ew_cc2540b.xcl
configuration PAN1721 Release (8051)
  as the first configuration, except:
  ICC8051.CCDefines: CC2541; INT_HEAP_LEN=1536
  ICC8051.CCIncludePath2: as above
  postbuild: ..\..\..\Tools\BrxBuilder.exe T="PAN1721" A="$TARGET_PATH$"
configuration PAN1721 Debug (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CC2541; INT_HEAP_LEN=1536; DEBUG; AT_DEBUG; OSALMEM_METRICS
  ICC8051.CCIncludePath2: as above
  XLINK.XclFile: ..\..\..\Tools\Linker\ti_51ew_cc2540b.xcl
  group App
    ../Source/: roboroach_app.c roboroach_devinfoservice.c roboroach_profile.c
  group Lib/CC2540
    ../../../Libraries/CC2540/: CC2540_ble_single_chip_all.lib
  group Lib/CC2540/BR-LE4.0-S2
    ../../../Libraries/CC2540/BR-LE4.0-S2/: AT.e-S2-Debug.lib AT.e-S2-Release.lib
  group Lib/CC2540/PAN1720
    ../../../Libraries/CC2540/PAN1720/: AT.e-PAN1720-Debug.lib AT.e-PAN1720-Release.lib
  group Lib/CC2541
    ../../../Libraries/CC2541/: CC2541_ble_single_chip_all.lib
  group Lib/CC2541/BR-LE4.0-S3
    ../../../Libraries/CC2541/BR-LE4.0-S3/: AT.e-S3-Debug.lib AT.e-S3-Release.lib
  group Lib/CC2541/PAN1721
    ../../../Libraries/CC2541/PAN1721/: AT.e-PAN1721-Debug.lib AT.e-PAN1721-Release.lib
  group Lib/Components/Osal
    ../../../../Components/osal/common/: OSAL_Memory.c
